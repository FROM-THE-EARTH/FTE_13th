# Repository FROM-THE-EARTH/FTE_13th

## EAGLE design 13thNSE2024/EAGLE/project/water/water.brd

Parts:
BMP1, BMP2, BMP3: BMP180; GY-68
CON1, CON8: 3PIN
CON10: 2PIN
SRIDE_SWTCH1: SRIDE_SWITCH
SV1: ML14L

Connections:
+3V3: BMP1.P1 (VIN), BMP2.P1 (VIN), BMP3.P1 (VIN), SV1.14
+5V: CON1.P$1, CON8.P$2, SV1.13
FP: CON10.P$1, SV1.6
GND: BMP1.P2 (GND), BMP2.P2 (GND), BMP3.P2 (GND), CON1.P$2, CON8.P$1, CON10.P$2, SRIDE_SWTCH1.LR, SV1.1, SV1.2
PITO: CON1.P$3, SV1.4
PWM: CON8.P$3, SV1.5
SCL0: BMP1.P3 (SCL), SV1.11
SCL1: BMP2.P3 (SCL), SV1.9
SCL2: BMP3.P3 (SCL), SV1.7
SDA0: BMP1.P4 (SDA), SV1.12
SDA1: BMP2.P4 (SDA), SV1.10
SDA2: BMP3.P4 (SDA), SV1.8
SW: SRIDE_SWTCH1.L, SV1.3

Board: 2 copper layers, 40.0 x 40.0 mm, 8 parts (0 on the bottom side), 13 nets.

## EAGLE design 13thNSE2024/EAGLE/project/Mother.ver2/MotherBoard.ver2.2.brd

Parts:
C1: 10uF; C0603
C6, C7: 3.3uF; C0603
CON1, CON2, CON3, CON4: 1.25CON2PIN
CON6: ML14L
D1, D2: 1N4148DO35-7; DO35-7
DCDC1: 5V1A_M78AR05-1
DCDC2: 3.3V1A_M78AR033-1
DOWN: PINHD-2X5; 2X05
LOG: PINHD-2X5; 2X05
MOS1, MOS2, MOS3, MOS4, MOS6, MOS7, MOS8: PCH_SSM6J808R; SSM6J808R
R1, R4, R12: 1k; R0603
R2, R3, R5, R6, R7, R32, R33: 10k; R0603
R15, R16: 100k; R0603
ROCKET: PINHD-2X5; 2X05
SW1: SRIDE_SWITCH

Connections:
3.3_RAW1: CON1.P$1, MOS7.4
3.3_RAW2: CON1.P$2, CON2.P$1
3.3_RAW3: CON3.P$1, MOS4.4
3.3_RAW4: CON3.P$2, CON4.P$1
+3V3: C6.1, CON6.14, DCDC2.VOUT, DOWN.9, LOG.9, MOS8.4, R3.2, R5.1, R6.2, R7.1, R32.2, R33.1, ROCKET.9
+5V: C7.1, CON6.13, DCDC1.VOUT, DOWN.10, LOG.10, ROCKET.10
+5V1: DCDC1.VIN, MOS1.1, MOS1.2, MOS1.5, MOS1.6
CANH: DOWN.1, LOG.1, ROCKET.1
CANL: DOWN.2, LOG.2, ROCKET.2
FP: CON6.6, D1.A, D2.A, MOS3.3, MOS4.3, MOS6.3, MOS7.3, MOS8.3, R4.2, R12.2
FP_CHECKER: C1.1, DOWN.5, LOG.5, R1.2, ROCKET.5
GND: C1.2, C6.2, C7.2, CON2.P$2, CON4.P$2, CON6.1, CON6.2, DCDC1.GND, DCDC2.GND, DOWN.7, LOG.7, R2.1, R4.1, R12.1, ROCKET.7, SW1.LR
unnamed: MOS8.1, MOS8.2, MOS8.5, MOS8.6, R1.1, R2.2
unnamed: D1.C, MOS1.4, MOS3.4, R16.2
unnamed: D2.C, MOS2.4, MOS6.4, R15.2
unnamed: MOS4.1, MOS4.2, MOS4.5, MOS4.6, MOS6.1, MOS6.2, MOS6.5, MOS6.6
unnamed: DCDC2.VIN, MOS2.1, MOS2.2, MOS2.5, MOS2.6
unnamed: MOS3.1, MOS3.2, MOS3.5, MOS3.6, MOS7.1, MOS7.2, MOS7.5, MOS7.6
PITO: CON6.4, DOWN.6
PWM: CON6.5, ROCKET.6
SCL0: CON6.11, DOWN.3, R33.2
SCL1: CON6.9, LOG.3, R5.2
SCL2: CON6.7, R7.2, ROCKET.3
SDA0: CON6.12, DOWN.4, R32.1
SDA1: CON6.10, LOG.4, R3.1
SDA2: CON6.8, R6.1, ROCKET.4
SW: CON6.3, MOS1.3, MOS2.3, R15.1, R16.1, SW1.L

Notes on the sheet:
PWR
SW,CON
FP_CHECKER

Board: 2 copper layers, 50.0 x 50.0 mm, 35 parts (17 on the bottom side), 27 nets.

## EAGLE design 13thNSE2024/EAGLE/project/DownLink/DownLink.ver1.brd

Parts:
BMX1: BMX055
C10, C11: 100nF; C1608
C12: 4.7uF; C1608
C13: 10nF; C1608
C22: 4.7nF; C0603
JP1: PINHD-1X5/90; 1X05/90
JP2: PINHD-2X5/90; 2X05/90
LED2, LED3: OSXX1608C1A
MODESW: SRIDE_SWITCH
PWR1: OSXX1608C1A
R8, R19: 10k; R0603
R20: 10k or DNF; R0603
R21, R22, R23: 100; R0603
R40, R41: 60; R0603
RESETSW: SRIDE_SWITCH
STM1: STM32F303K8
U$1: NEWGPS
U$3: RM-92A
U$5: DIP762W45P254L949H533Q8B

Connections:
+3V3: BMX1.3V3, BMX1.VCC, BMX1.VCCIO, C10.1, C11.1, C12.1, C13.1, JP1.1, JP2.9, PWR1.AN, R20.2, STM1.VDD, STM1.VDD2, STM1.VDDA, U$3.VCC, U$3.VDDRF, U$5.5 (VIO)
+5V: JP2.10, U$1.5V, U$5.3 (VDD)
BOOT1: R19.1, STM1.BOOT (BOOT0)
CANH: JP2.1, R40.2, U$5.7 (CANH)
CANL: JP2.2, R41.2, U$5.6 (CANL)
FP_CHECKER: JP2.5, STM1.PB4
GND: BMX1.GND, C10.2, C11.2, C12.2, C13.2, C22.2, JP1.2, JP2.7, MODESW.LR, R8.1, R19.2, R21.1, R22.1, R23.1, RESETSW.LR, STM1.VSS, STM1.VSS2, U$1.GND, U$3.GND1, U$3.GND2, U$5.2 (VSS), U$5.8 (STBY)
GPSRX: STM1.PA2/UART2_TX, U$1.RX
GPSTX: STM1.PA3/UART2_RX, U$1.TX
LED1.0: LED2.AN, STM1.PB0
LED1.1: LED3.AN, STM1.PB1
unnamed: MODESW.R, U$3.PC13
unnamed: RESETSW.R, U$3.RESET_N
unnamed: R8.2, U$3.BOOT0
unnamed: PWR1.CT, R21.2
unnamed: LED2.CT, R22.2
unnamed: LED3.CT, R23.2
unnamed: C22.1, R40.1, R41.1
NRST1: R20.1, STM1.NRST
OSC_IN1: STM1.PF0
OSC_OUT1: STM1.PF1
RFRX: STM1.PA9/UART1_TX, U$3.PA10
RFTX: STM1.PA10/UART1_RX, U$3.PA9
RXCAN1: STM1.PA12/CAN_TX, U$5.4 (RXD)
SCL1: BMX1.SCL, JP2.3, STM1.PA15/I2C1_SCL
SDA1: BMX1.SDA, JP2.4, STM1.PB7/I2C1_SDA
SWCLK1: JP1.4, STM1.PA14/SWCLK
SWDIO1: JP1.5, STM1.PA13/SWDIO
SWO1: JP1.3, STM1.PB3/SWO (PB3/TRACESWO)
TXCAN1: STM1.PA11/CAN_RX, U$5.1 (TXD)

Notes on the sheet:
near VDD
near VDD2
near VDDA
PWR Check
DOWNLINK
ST_link

Board: 2 copper layers, 40.0 x 50.0 mm, 25 parts (4 on the bottom side), 28 nets.

## EAGLE design 13thNSE2024/EAGLE/project/DataLog/DataLogger.ver1.brd

Parts:
BMX1: BMX055
C1, C2: 100nF; C1608
C3: 4.7uF; C1608
C4: 10nF; C1608
CN1: DM3AT
JP2: PINHD-2X5/90; 2X05/90
JP3: PINHD-1X5/90; 1X05/90
LED0, LED1: OSXX1608C1A
PWR: OSXX1608C1A
R1, R7, R8, R9, R10: 10k; R0603
R2: 10k or DNF; R0603
R3, R5, R6, R11: 100; R0603
STM0: STM32F303K8
U$3: DIP762W45P254L949H533Q8B
U$4: F.T.E.LOGO; LOGO

Connections:
+3V3: BMX1.3V3, BMX1.VCC, BMX1.VCCIO, C1.1, C2.1, C3.1, C4.1, CN1.VDD, JP2.9, JP3.1, PWR.AN, R2.2, R7.2, R8.2, R9.2, R10.2, STM0.VDD, STM0.VDD2, STM0.VDDA, U$3.5 (VIO)
+5V: JP2.10, U$3.3 (VDD)
BOOT0: R1.1, STM0.BOOT (BOOT0)
CANH: JP2.1, U$3.7 (CANH)
CANL: JP2.2, U$3.6 (CANL)
FP_CHECKER: JP2.5, STM0.PB4
GND: BMX1.GND, C1.2, C2.2, C3.2, C4.2, CN1.VSS, JP2.7, JP3.2, R1.2, R3.1, R5.1, R6.1, STM0.VSS, STM0.VSS2, U$3.2 (VSS), U$3.8 (STBY)
LED0: LED0.AN, STM0.PB0
LED1: LED1.AN, STM0.PB1
LOGRX: STM0.PA9/UART1_TX
LOGTX: STM0.PA10/UART1_RX
MISO: CN1.DAT0, R10.1, STM0.PA6/SPI1_MISO
MOSI: CN1.CMD, R8.1, STM0.PA7/SPI1_MOSI
unnamed: PWR.CT, R3.2
unnamed: LED0.CT, R5.2
unnamed: LED1.CT, R6.2
unnamed: CN1.CLK, R9.1, R11.2
NRST0: R2.1, STM0.NRST
NSS: CN1.CD/DAT3, R7.1, STM0.PA4/SPI1_NSS
PITO: JP2.6
RXCAN: STM0.PA12/CAN_TX, U$3.4 (RXD)
SCK: R11.1, STM0.PA5/SPI1_SCK
SCL0: BMX1.SCL, JP2.3, STM0.PA15/I2C1_SCL
SDA0: BMX1.SDA, JP2.4, STM0.PB7/I2C1_SDA
SWCLK: JP3.4, STM0.PA14/SWCLK
SWDIO: JP3.5, STM0.PA13/SWDIO
SWO: JP3.3, STM0.PB3/SWO (PB3/TRACESWO)
TXCAN: STM0.PA11/CAN_RX, U$3.1 (TXD)

Notes on the sheet:
near VDD
near VDD2
near VDDA
PWR Check
SD(アップリンクは２kのほうがいい）
CPU
datalogger
ST_link

Board: 2 copper layers, 40.0 x 50.0 mm, 24 parts (5 on the bottom side), 25 nets.

## EAGLE design TRC2024/Rowpro/newGPS/GPS Module_2.brd

Parts:
BATT1: CR2032_PLATE
C1: 4.7u; C0603
C2, C6: 0.1u; C0603
C3: 1u; C0603
C4, C5: 10u; C0603
D1: timer; SOD-123
D2: en; SOD-123
D3: power; SOD-123FL
GPS1: L80-M39; L80
JP1: PINHD-1X6; 1X06
L1: OSXX1608C1A
MOS1: AO3401A; SOT-23
R1: 1k; R0603
R2: 100; R0603
R3, R4, R5: 10k; R0603
R6: NC; R0603
REG1: AP7375; SOT23

Connections:
+3V3: C4.1, MOS1.S, R3.2, R4.2, R5.2, R6.1, REG1.VOUT
+5V: C3.1, D3.C, JP1.1, REG1.VIN
BACK: BATT1.VCC, C1.1, C2.1, GPS1.V_BCKP, R1.1
EN: D2.C, JP1.6, R5.1
GND: BATT1.GND, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, GPS1.GND_0 (GND_1), GPS1.GND_1 (GND_2), JP1.2, L1.CT, REG1.GND
unnamed: D3.A, R1.2
unnamed: D1.A, D2.A, MOS1.G
unnamed: L1.AN, R2.1
PPS: GPS1.1PPS, R2.2
RST: GPS1.RESET, JP1.5, R3.1
RX: GPS1.RXD1, JP1.4
SUP: C5.1, C6.1, GPS1.VCC, MOS1.D, R6.2
TIMER: D1.C, GPS1.TIMER, R4.1
TX: GPS1.TXD1, JP1.3

Board: 2 copper layers, 33.0 x 27.9 mm, 21 parts (5 on the bottom side), 14 nets.

## EAGLE design TRC2024/Rowpro/ig-normal/PCB_01/ig-normal-ver13_PWM_UARTexpantion.brd

Parts:
ADC: MCP3425; SOT23-6
BMP1: BMP180; GY-68
BMX1: BMX055
C1, C2: 10uF; C0603
C3: 10μF; C0603
C4: 22μF; C0805
CON1: ML10L
CON2: ML14L
JP1: PINHD-2X4; 2X04
L1, L3: OSXX1608C1A
MD1, MD2, MD3, MD4: BD6222HFP-TR
MDSW: SRIDE_SWITCH
MOS1, MOS2, MOS3, MOS4: PCH_SSM6J808R; SSM6J808R
PW: 2PIN
R2, R3: 1k; R0603
R4, R5: 1.2k; R0603
R8: 10k; R0603
R10, R11: 100k; R0603
R12, R14: 100; R0603
R18: BAT; R0603
R19: COM; R0603
RASPPI: RASPBERYPIZEROW
RPSW: SRIDE_SWITCH
TD1: 3.6v; UDZV3.6V
U1: MAX7315AUET; SOP65P640X110-16N
U$1: OKL-T/6-W12N-C_RE; MURATA_IKL-T-6-W12N-C_0_RECOMENDED

Connections:
+3V3: ADC.5 (VDD), BMP1.P1 (VIN), BMX1.3V3, BMX1.VCC, BMX1.VCCIO, R2.1, R3.1, RASPPI.3.3V1 (3V3-1), RASPPI.3.3V2 (3V3-2), U1.16 (V+)
+5V: C3.1, CON1.6, CON1.8, CON2.6, CON2.9, JP1.1, R4.2, RASPPI.5V1 (5V-1), RASPPI.5V2 (5V-2), U$1.4_VOUT, U$1.5_SENSE
+7.4V: C1.1, C2.1, MD1.VCC, MD1.VREV (VREF), MD2.VCC, MD2.VREV (VREF), MD3.VCC, MD3.VREV (VREF), MD4.VCC, MD4.VREV (VREF), MOS2.1, MOS2.2, MOS2.5, MOS2.6
A1: ADC.1 (VIN+), R18.1, R19.2, TD1.C
BATT: MOS1.1, MOS1.2, MOS1.5, MOS1.6, MOS3.1, MOS3.2, MOS3.5, MOS3.6, PW.P$2, R18.2
CE: JP1.6, RASPPI.GPIO8
COMV: C4.1, MOS4.1, MOS4.2, MOS4.5, MOS4.6, R8.2, U$1.2_VIN
GND: ADC.2 (VSS), ADC.6 (VIN-), BMP1.P2 (GND), BMX1.GND, C1.2, C2.2, C3.2, C4.2, CON1.5, CON1.7, CON2.7, CON2.8, JP1.2, L1.CT, L3.CT, MD1.BGND, MD1.GND, MD2.BGND, MD2.GND, MD3.BGND, MD3.GND, MD4.BGND, MD4.GND, MDSW.LR, MOS1.3, MOS3.3, PW.P$1, R4.1, R5.1, R8.1, R19.1, RASPPI.GND1, RASPPI.GND2, RASPPI.GND3, RASPPI.GND4, RASPPI.GND5, RASPPI.GND6, RASPPI.GND7, RPSW.LR, TD1.A, U1.1 (AD0), U1.2 (AD1), U1.3 (AD2), U1.8 (GND), U$1.1_ON/OFF, U$1.3_GND (3_GROUND), U$1.7_GND
GPS_RST: CON1.2, RASPPI.GPIO21
GPS_RX: CON1.3, RASPPI.GPIO15
GPS_TRIG: CON1.1, RASPPI.GPIO20
GPS_TX: CON1.4, RASPPI.GPIO14
INT: RASPPI.GPIO19, U1.13 (!INT/08)
LED0: R12.1, RASPPI.GPIO22
LED2: R14.1, RASPPI.GPIO26
MD1_F: MD1.FIN, U1.4 (P0)
MD1_O1: CON2.1, MD1.OUT1
MD1_O2: CON2.2, MD1.OUT2
MD1_R: MD1.RIN, U1.5 (P1)
MD2_F: MD2.FIN, U1.6 (P2)
MD2_O1: CON2.4, MD2.OUT1
MD2_O2: CON2.3, MD2.OUT2
MD2_R: MD2.RIN, U1.7 (P3)
MD3_F: MD3.FIN, U1.9 (P4)
MD3_O1: CON2.11, MD3.OUT1
MD3_O2: CON2.12, MD3.OUT2
MD3_R: MD3.RIN, U1.10 (P5)
MD4_F: MD4.FIN, U1.11 (P6)
MD4_O1: CON2.14, MD4.OUT1
MD4_O2: CON2.13, MD4.OUT2
MD4_R: MD4.RIN, U1.12 (P7)
MISO: JP1.4, RASPPI.GPIO9
MOSI: JP1.3, RASPPI.GPIO10
unnamed: MOS3.4, MOS4.4, R11.2
unnamed: MDSW.L, MOS4.3, R11.1
unnamed: L1.AN, R12.2
unnamed: L3.AN, R14.2
unnamed: MOS1.4, MOS2.4, R10.2
unnamed: MOS2.3, R10.1, RPSW.L
SCL: ADC.4 (SDA), BMP1.P3 (SCL), BMX1.SCL, JP1.7, R2.2, RASPPI.GPIO3, U1.14 (SCL)
SCLK: JP1.5, RASPPI.GPIO11
SDA: ADC.3 (SCL), BMP1.P4 (SDA), BMX1.SDA, JP1.8, R3.2, RASPPI.GPIO2, U1.15 (SDA)
SV0: CON1.9, RASPPI.GPIO12
SV1: CON2.10, RASPPI.GPIO13
SV2: CON2.5, RASPPI.GPIO18
TRIM: R5.2, U$1.6_TRIM

Notes on the sheet:
CPU
SENSORS
PWSUPPLY
SWITCHES_CONNECTORS
main_board
motorswitch
comswitch
LEDS
connector

Board: 2 copper layers, 33.0 x 67.0 mm, 38 parts (12 on the bottom side), 46 nets.
