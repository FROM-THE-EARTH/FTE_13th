# Repository FROM-THE-EARTH/FTE_13th (continued)

## EAGLE design 13thIZU2024/PCB/13thISE.ver11.brd

Parts:
BMP1, BMP2, BMP3: BMP180; GY-68
BMX1, BMX2: BMX055
C1, C2, C10, C11, C15, C16: 100nF; C1608
C3, C12, C17: 4.7uF; C1608
C4, C13, C18: 10nF; C1608
C5, C14, C19: 0.1uF; C1608
C6, C7, C9: 3.3uF; C0603
C8: 10uF; C0603
C22: 4.7nF; C0603
CN1: DM3AT
CON1, CON2, CON3, CON4, CON5: 2PIN
D1, D2, D3: 1N4148DO35-7; DO35-7
DCDC1: 5V1A_M78AR05-1
DCDC2, DCDC3: 3.3V1A_M78AR033-1
IM1: IM920_IM920C
JP1, JP3, JP4: JP3Q
LED0, LED1, LED2, LED3, LED4, LED5, LED6: OSXX1608C1A
MOS1, MOS2, MOS3, MOS4, MOS5, MOS6, MOS7, MOS8, MOS9, MOS10: PCH_SSM6J808R; SSM6J808R
PWR, PWR1, PWR2: OSXX1608C1A
R1, R7, R8, R9, R10, R14, R19, R25, R30, R31, R32, R33, R34, R35: 10k; R0603
R2, R20, R26: 10k or DNF; R0603
R3, R5, R6, R11, R21, R22, R23, R24, R27, R28, R29: 100; R0603
R4, R12, R13, R17: 1k; R0603
R15, R16, R18: 100k; R0603
R40, R41: 60; R0603
RST, RST1, RST2: TVAF06-A020B-R
STM0, STM1: STM32F303K8
SV: 3PIN
SW1: SRIDE_SWITCH
U$1: STM32F303K8
U$2: AE-GYSFDMAXB
U$3, U$5, U$6: DIP762W45P254L949H533Q8B
U$4: F.T.E.LOGO; LOGO

Connections:
3.3_RAW1: CON4.P$2, MOS7.4
3.3_RAW2: CON1.P$2, CON4.P$1
3.3_RAW3: CON2.P$2, MOS4.4
3.3_RAW4: CON3.P$2, MOS8.4
+3V3: BMP1.P1 (VIN), BMP2.P1 (VIN), BMP3.P1 (VIN), BMX1.3V3, BMX1.VCC, BMX1.VCCIO, BMX2.3V3, BMX2.VCC, BMX2.VCCIO, C1.1, C2.1, C3.1, C4.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, CN1.VDD, DCDC2.VOUT, DCDC3.VOUT, IM1.$P17 (VCC), JP1.2, JP3.2, JP4.2, MOS5.4, PWR.AN, PWR1.AN, PWR2.AN, R2.2, R7.2, R8.2, R9.2, R10.2, R20.2, R26.2, R30.2, R31.1, R32.2, R33.1, R34.2, R35.1, STM0.VDD, STM0.VDD2, STM0.VDDA, STM1.VDD, STM1.VDD2, STM1.VDDA, U$1.VDD, U$1.VDD2, U$1.VDDA, U$3.5 (VIO), U$5.5 (VIO), U$6.5 (VIO)
+5V: C7.1, DCDC1.VOUT, SV.P$2, U$2.P1 (5V), U$3.3 (VDD), U$5.3 (VDD), U$6.3 (VDD)
+5V1: DCDC1.VIN, MOS1.1, MOS1.2, MOS1.5, MOS1.6
BOOT0: R1.1, STM0.BOOT (BOOT0)
BOOT1: R19.1, STM1.BOOT (BOOT0)
BOOT2: R25.1, U$1.BOOT (BOOT0)
CANH: R40.2, U$3.7 (CANH), U$5.7 (CANH), U$6.7 (CANH)
CANL: R41.2, U$3.6 (CANL), U$5.6 (CANL), U$6.6 (CANL)
FP: CON5.P$1, D1.A, D2.A, D3.A, MOS3.3, MOS4.3, MOS5.3, MOS6.3, MOS7.3, MOS8.3, MOS9.3, R4.2, R12.2, R17.2
FP_CHECKER: C8.1, R13.2, STM0.PB4, STM1.PB4, U$1.PB4
GND: BMP1.P2 (GND), BMP2.P2 (GND), BMP3.P2 (GND), BMX1.GND, BMX2.GND, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C22.2, CN1.VSS, CON1.P$1, CON2.P$1, CON3.P$1, CON5.P$2, DCDC1.GND, DCDC2.GND, DCDC3.GND, IM1.$P18 (GND), JP1.6, JP3.6, JP4.6, R1.2, R3.1, R4.1, R5.1, R6.1, R12.1, R14.1, R17.1, R19.2, R21.1, R22.1, R23.1, R24.1, R25.2, R27.1, R28.1, R29.1, RST.P$2, RST1.P$2, RST2.P$2, STM0.VSS, STM0.VSS2, STM1.VSS, STM1.VSS2, SV.P$3, SW1.LR, U$1.VSS, U$1.VSS2, U$2.P2 (GND), U$3.2 (VSS), U$3.8 (STBY), U$5.2 (VSS), U$5.8 (STBY), U$6.2 (VSS), U$6.8 (STBY)
GPSRX: STM1.PA2/UART2_TX, U$2.P3 (RXD)
GPSTX: STM1.PA3/UART2_RX, U$2.P4 (TXD)
IM_BUSY: IM1.$P1 (BUSY/IO1), STM1.PA5/SPI1_SCK
IM_RESET: IM1.$P19 (RESET), STM1.PA6/SPI1_MISO
IM_RX: IM1.$P6 (RXD/IO6), STM1.PA9/UART1_TX
IM_TX: IM1.$P7 (TXD/IO7), STM1.PA10/UART1_RX
LED: IM1.$P15 (STATUS), LED4.AN
LED0: LED0.AN, STM0.PB0
LED1: LED1.AN, STM0.PB1
LED1.0: LED2.AN, STM1.PB0
LED1.1: LED3.AN, STM1.PB1
LED2.0: LED5.AN, U$1.PB0
LED2.1: LED6.AN, U$1.PB1
LOGRX: STM0.PA9/UART1_TX, U$1.PA10/UART1_RX
LOGTX: STM0.PA10/UART1_RX, U$1.PA9/UART1_TX
MISO: CN1.DAT0, R10.1, STM0.PA6/SPI1_MISO
MOSI: CN1.CMD, R8.1, STM0.PA7/SPI1_MOSI
unnamed: PWR.CT, R3.2
unnamed: LED0.CT, R5.2
unnamed: D1.C, MOS1.4, MOS3.4, R16.2
unnamed: LED1.CT, R6.2
unnamed: D2.C, MOS2.4, MOS6.4, R15.2
unnamed: MOS4.1, MOS4.2, MOS4.5, MOS4.6, MOS6.1, MOS6.2, MOS6.5, MOS6.6
unnamed: CN1.CLK, R9.1, R11.2
unnamed: DCDC2.VIN, MOS2.1, MOS2.2, MOS2.5, MOS2.6
unnamed: D3.C, MOS9.4, MOS10.4, R18.2
unnamed: MOS8.1, MOS8.2, MOS8.5, MOS8.6, MOS9.1, MOS9.2, MOS9.5, MOS9.6
unnamed: PWR2.CT, R27.2
unnamed: MOS3.1, MOS3.2, MOS3.5, MOS3.6, MOS7.1, MOS7.2, MOS7.5, MOS7.6
unnamed: DCDC3.VIN, MOS10.1, MOS10.2, MOS10.5, MOS10.6
unnamed: MOS5.1, MOS5.2, MOS5.5, MOS5.6, R13.1, R14.2
unnamed: PWR1.CT, R21.2
unnamed: LED2.CT, R22.2
unnamed: LED3.CT, R23.2
unnamed: LED4.CT, R24.2
unnamed: LED5.CT, R28.2
unnamed: LED6.CT, R29.2
unnamed: C22.1, R40.1, R41.1
NRST0: C5.1, R2.1, RST.P$1, STM0.NRST
NRST1: C14.1, R20.1, RST1.P$1, STM1.NRST
NRST2: C19.1, R26.1, RST2.P$1, U$1.NRST
NSS: CN1.CD/DAT3, R7.1, STM0.PA4/SPI1_NSS
OSC_IN1: STM1.PF0
OSC_IN2: U$1.PF0
OSC_OUT1: STM1.PF1
OSC_OUT2: U$1.PF1
PWM: SV.P$1, U$1.PA5/SPI1_SCK
RXCAN: STM0.PA12/CAN_TX, U$3.4 (RXD)
RXCAN1: STM1.PA12/CAN_TX, U$5.4 (RXD)
RXCAN2: U$1.PA12/CAN_TX, U$6.4 (RXD)
SCK: R11.1, STM0.PA5/SPI1_SCK
SCL0: BMP1.P3 (SCL), BMX1.SCL, R33.2, STM0.PA15/I2C1_SCL
SCL1: BMP3.P3 (SCL), R35.2, STM1.PA15/I2C1_SCL
SCL2: BMP2.P3 (SCL), BMX2.SCL, R31.2, U$1.PA15/I2C1_SCL
SDA0: BMP1.P4 (SDA), BMX1.SDA, R32.1, STM0.PB7/I2C1_SDA
SDA1: BMP3.P4 (SDA), R34.1, STM1.PB7/I2C1_SDA
SDA2: BMP2.P4 (SDA), BMX2.SDA, R30.1, U$1.PB7/I2C1_SDA
SW: MOS1.3, MOS2.3, MOS10.3, R15.1, R16.1, R18.1, SW1.L
SWCLK: JP1.3, STM0.PA14/SWCLK
SWCLK1: JP3.3, STM1.PA14/SWCLK
SWCLK2: JP4.3, U$1.PA14/SWCLK
SWDIO: JP1.1, STM0.PA13/SWDIO
SWDIO1: JP3.1, STM1.PA13/SWDIO
SWDIO2: JP4.5, U$1.PA13/SWDIO
SWO: JP1.5, STM0.PB3/SWO (PB3/TRACESWO)
SWO1: JP3.5, STM1.PB3/SWO (PB3/TRACESWO)
SWO2: JP4.1, U$1.PB3/SWO (PB3/TRACESWO)
TXCAN: STM0.PA11/CAN_RX, U$3.1 (TXD)
TXCAN1: STM1.PA11/CAN_RX, U$5.1 (TXD)
TXCAN2: U$1.PA11/CAN_RX, U$6.1 (TXD)

Notes on the sheet:
near VDD
near VDD2
near VDDA
PWR Check
SD(アップリンクは２kのほうがいい）
CPU
datalogger
PWR
SW,CON
FP_CHECKER
IM920c
DOWNLINK
Rocket_controller
ST_link

Board: 2 copper layers, 120.0 x 120.0 mm, 111 parts (8 on the bottom side), 81 nets.

## Code that names these connections

File 13thIZU2024/STM32/software/DataLoggerISE2024_ver1/DataLoggerISE2024_ver1.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.Mode=SYS_WakeUp0
PA0.Signal=SYS_WKUP1
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Pu
PA15.GPIO_Pu=GPIO_NOPULL
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_PuPd
PA5.GPIO_PuPd=GPIO_NOPULL
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_PuPd
PA6.GPIO_PuPd=GPIO_PULLUP
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.GPIOParameters=GPIO_PuPd
PA7.GPIO_PuPd=GPIO_PULLUP
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PB0.Signal=GPIO_Output
PB1.Signal=GPIO_Output
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB4.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_Pu
PB7.GPIO_Pu=GPIO_NOPULL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=32000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File 13thIZU2024/STM32/software/GPS_Check.ver1/GPS_Check.ver1.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.Mode=SYS_WakeUp0
PA0.Signal=SYS_WKUP1
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Pu
PA15.GPIO_Pu=GPIO_PULLUP
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB7.GPIOParameters=GPIO_Pu
PB7.GPIO_Pu=GPIO_PULLUP
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File TRC2024/Rowpro/ig-normal/software_2/main3(.py (part):

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SERVO0_RESET = 60 #initial (from 44 to 232)
SERVO0_SET = 180 #moving

LED0 = 22
LED1 = 19
LED2 = 26
MD_LF0 = 5
MD_LB0 = 6
MD_RF0 = 17
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        if phase == 0.0:
            #phase0
            print("main():         Phase0 start. flying")
            GPIO.output(LED0, 1)
            while True:
                restTime = time.time() - start
                if flying() == False:
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            #phase1
            print("main():         Phase1 start. release")
            release() #パラ分離&スタビライザー開放
            GPIO.output(LED0, 0)
            
            phase = 2.0

        elif phase == 2.0:
            #phase2
            print("main():         Phase2 start. caibration")
            GPIO.output(LED0, 1)
            calibration() #地磁気補正
            #phase = 3.0
        
        elif phase == 3.0:
            #phase3
            print("main():         Phase3 start. mode of gps")
            GPIO.output(LED0, 0)
            if cameraFlag == True:
                while True:
                    if distance<10: #目的地との距離が10m以下ならばphase4へ
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        elif phase == 4.0:
            #phase4
            print("main():         Phase4 start. reset pos")
            GPIO.output(LED0, 1)
            resetFlag = resetPos()
            if resetFlag == True:
                phase = 5.0
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            #phase6
            print("main():         Goal!")
            phase = 6.0
            GPIO.output(LED2,1) #ゴールLED点灯
            time.sleep(100000)

        else:
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    GPIO.setmode(GPIO.BCM)

    # LEDピンを出力に設定
    GPIO.setup(LED0, GPIO.OUT)
    GPIO.setup(LED2, GPIO.OUT)
    GPIO.output(LED0, 0)
    GPIO.output(LED2, 0)
    
    gpsThread = threading.Thread(target=setGpsData_thread1, args=()) # 上の関数を実行するスレッドを生成
    gpsThread.daemon = True
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
## Commit log

2022-08-06 Create aaa
2022-08-19 Create 新プロPCB
2023-05-01 Create NSE2023
2023-05-09 Update NSE2023
2023-10-30 13th TRC2024CanSatPCB
    13th TRC2024CanSatPCB
2023-10-30 13thTRC2024
2023-10-30 13th CanSatPCB
    3ServoMotors
2023-11-01 "Via"changed
    "Via"changed
2023-11-02 ISE2024PCB
    試作品
2023-11-02 board
    ボードの設計しました。
2023-11-02 error
    エラー直しました
2023-11-04 RowPro
    PCBData
2023-11-04 PCB
    connected to Library.io
2023-11-04 SVmotor
    13thのためにSVportを３つ付けました
2023-11-04 UART
    ダウンリンカーとデータロガーをUARTで繋いだ
2023-11-04 CAN
    can通信を入れた。
2023-11-05 renov
2023-11-07 CAN
    CAN通信を少し変えた
2023-11-07 SDcard
    SDカード修正
2023-11-08 edit
2023-11-09 SDcard
    SDの抵抗とCANの終端抵抗の変更
2023-11-13 nothing
2023-11-29 edit brd
2023-11-29 add GPS
2023-11-29 added cam
2023-11-29 add schem
2024-01-15 bmp180
    9軸を抜いたロケット制御
2024-03-04 ig-normal
    分離のプログラム
2024-03-04 main
    ビデオが撮れるメインの関数
2024-03-12 program
    本番
2024-03-14 Update main.c
    im920sl用のwirelessSend関数と、それに関連する部分の加筆
2024-04-19 NSE2024Eagle
2024-04-19 DataLog
2024-04-23 DownLink
2024-04-25 MotherBoard
2024-04-25 Mother.ver2
2024-04-25 rocketcontroll
2024-04-25 mother
2024-04-26 water
2024-08-18 Add file NSE24.GPS/DownLink.soft
2024-10-18 STMproject
2026-02-07 Create TRC2026
2026-02-07 TRC2026
2026-02-11 自動調整試作１
    カメラの自動調整試作版（GPT作）
2026-02-11 ラズパイ生コード
    mainはhaggy19
